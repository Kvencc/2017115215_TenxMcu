# Keil uVision project 综合测试.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89F52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: 综合测试 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c 18b20.c delay.c DS1302.c i2c.c keyboard.c uart.c pcf8591.c LED8x8.c timer.c 1602.c
