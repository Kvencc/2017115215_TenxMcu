# Keil uVision project 步进电机转动原理.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(33000000) MODAT2
  output: 步进电机转动原理 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 步进电机转动原理.c
