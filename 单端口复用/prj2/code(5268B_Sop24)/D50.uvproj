# Keil uVision project D50.uvproj, settings and files
target Target 1 (MCS-51)
  device: TM52F5268C tenx
  cpu: IRAM(0-0xFF) CLOCK(8000000)
  output: D50 +hex
  c flags: Optimize=6 SizeSpeed=1
  group Source Group 1
    ./: STARTUP_TENX52.A51 isr.c tkjudgement.c tkcalculate.OBJ buzz.c display.c tempAd.c main.c triac.c updatebaseline.c TM1628.c
