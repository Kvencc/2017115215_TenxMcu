# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: TM52F5278 tenx
  cpu: IRAM(0-0xFF) CLOCK(8000000) XRAM(0xFF00-0xFFFF)
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Source Group 1
    ./: STARTUP_TENX52.A51
    ./src/: test.c AT2402.c AT93C46.c led_driver.c IrDA_receive.c music.c
