# Keil uVision project 数码管模拟水流.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(33000000) MODAT2
  output: 数码管模拟水流 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../25-数码管显示动态数据/: 数码管显示动态数据.c
    ../26-9累加/: 9累加.c
    ../35-数码管消隐/: 数码管消隐.c
